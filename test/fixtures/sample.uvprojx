# Keil uVision project sample.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F103C8
  group App
    ./App/: main.c util.h
  group Drivers
    ./Drivers/: startup.s
